Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2026-04-13T08:50:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.2.1.0 - Alternative Benutzeroberfläche 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 13 08:50:19 2026 * Host: CAD-NB-is-2025 * Database: C:\Temp\d144aa58-3233-47d9-9ea9-597f7b866be9\59647e36-6051-4b00-b835-fc90da7e9e86\ifc * Database version: 5507 * Database creation date: Mon Apr 13 08:50:18 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 13 08:50:18 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 13 08:50:18 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 46, 54, 59, 757385; RefLongitude: 7, 27, 59, 759788; RefElevation: 0 m

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
LongName: Ebene 0; Elevation: 0 m

# IfcBuildingElementProxy: MS-G-90-RE:Grillplatte hartchrom_MS-G-90, MS-G-90-RE:Grillplatte hartchrom_MS-G-90:360624
In: Ebene 0
Type - Material: <Unnamed>, MS_Finishes_Red, MS_Finishes_Alu, MS_Finishes_Stainless_Steel, MS_Finishes_Black_matt, MS_Finishes_Black_shiny, MS_Glass_Red, MS_Glass_Green
Type - BaseQuantities Elektro - Elektrischer Anschluss Anschlusshöhe: 0 m; Hauptschalter integriert: no; Maximale Geräteabsicherung: 0 A; Minimale Stromaufnahme: 0 A; Spannung: 400 V; Zuleitung zum Gerät im Lieferumfang: yes; Anzahl der Pole: 3; Elektrische Leistung: 9000 W; Frequenz: 50 Hz; Scheinleistung: 9000 W; Stecker System: Typ 25 oder CEE 16
Type - BaseQuantities HLS - Latente Abwärme Belastung: 31968.8; Sensible Abwärme Belastung: 38750.1
Type - BaseQuantities Allgemein - Höhe: 0.2 m; Länge Gerätebreite: 0.9 m; Tiefe: 0.6 m
Type - BaseQuantities ID-Daten - Großküchengerätezuordnung: yes; Artikel Nummer: 311581; Gerätegewicht Netto: 95; Internetadresse für die Maßzeichnung: https://www.menu-system.com/de/hauptseiten/einzelgeraete/einzelgeraeete-produkte/grill.html#4303; Modell: Grillplatte hartchrom MS-G-90; Hersteller: Menu System AG; Typenkommentare: MS-G-90; Beschreibung: Grillplatte hartchrom 90*60cm mit 2 Heizzonen, 9kW

# IfcDistributionPort, Port_360624
Description: Flow; FlowDirection: SOURCEANDSINK
